inherit vulnscout improve_kernel_cve_report